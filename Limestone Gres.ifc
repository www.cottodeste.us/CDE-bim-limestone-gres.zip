Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], ExchangeRequirement[Architecture]
File name: F:/BIM PGR/BIM COTTO D'ESTE/LIMESTONE/Limestone Gres/Limestone Gres.ifc
Time: 2021-01-29T12:24:18
Author: Architect
Organization: Nemetschek Vectorworks, Inc.
Written by: Vectorworks Architect 2021 SP2 R1 (Build 574483) (64-Bit) by Vectorworks, Inc.
Made in: Windows

# IfcSite, Sito standard
RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0

# IfcBuilding, Edificio standard
Pset_BuildingCommon - SprinklerProtection: no; SprinklerProtectionAutomatic: no; NumberOfStoreys: 1; IsLandmarked: no

# IfcBuildingStorey, Piano 1
In: Edificio standard
Elevation: 0 mm
Pset_BuildingStoreyCommon - EntranceLevel: no; AboveGround: yes; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2

# IfcCovering: full body porcelain stoneware (UGL) (52)
In: Piano 1
Description: Porcelain stoneware tiles; PredefinedType: USERDEFINED; Material: Default
OtherThecnicalFeatures - ApparentDensity: 2,3 - 2,5 g/cm3; ChemicalResistance: LA, HA RESISTANT; CompressionResistance: n/a; CrazingResistance: Pass; DeepAbrasionResistance: 143mm3; DimensionsLengthAndWidth: ± 0,3 %, max ± 1 mm; DimensionsRectangularity: ± 0,3 %, max ± 1,5 mm; DimensionsStraightness: ± 0,3 %, max ± 0,8 mm; DimensionsSurfaceFlatness: ± 0,4 %, max ± 1,8 mm; DimensionsThickness: ± 5 % ± 0,5mm; ElectricalConductivity: n/a; FrostResistance: Resistant; HardnessMohsScale: n/a; ImpactResistance: n/a; Light ReflectanceValueLRV: On request; LightAndColourFastness: Pass; LinearThermalExpansion: α ≤ 7·10-6 °C-1; ModulusOfRupture: 50 N/mm2; MoistureExpansion: n/a; PhotocatalyticProperties: n/a; StainsResistance: 5 RESISTANT; SurfaceAbrasionResistance: n/a; SurfaceQuality: n/a; ThermalConductivity: 1,3 W/m °K; TotalPorosity: n/a; WaterAbsorption: 0,05 %
EnvironmentalSustainability - AsbestosFreeMaterial: yes; CAMCompliantDeclaration: On request (EPD); Ecolabel UE: no; EcolabelCertification: n/a; EMASCertification/Document: https://www.cottodeste.it/download#certificazioni; EnvironmentalProductDeclarationEPD: yes; EPDDocument: On request; EPDType: Product-Specific Type III EPD; FicheDeDéclarationEnvironnementaleEtSanitaireFDESCertification: n/a; FormaldehydeFreeMaterial: yes; HealthProductDeclarationHPDCertification/self declaration: On request; ISO45001Certification: n/a; ISO50001Certification: n/a; ISO9001Certification: https://www.cottodeste.it/download#certificazioni; RawMaterialSourceAndExtractionDocument: On request; REACHCompliant: yes; RecyclableProductPackaging: yes; RecycledContentPreconsumerCertification: https://www.cottodeste.it/download#certificazioni; SolarReflectance_After3YearValue: On request; SolarReflectance_InitialValue: On request; SolarReflectanceCertification: n/a; SolarReflectanceIndexSRICertification: On request; VOCIndoorAirQualityCertification: On request; ZeroVOCMineralBasedProduct: yes
DoP&ProductCertification - BondStrengthAdhesion: NPD; CEMarking: yes; CertificateNumber: n/a; DeclarationPerformanceNumber: DOP001EST; DurabilityExternalUseFreezeThawResistance: Passed; DurabilityForInternalUse: Passed; HarmonizedTechnicalSpecification: EN 14411:2012; Intended Use: Ceramic tiles for flooring and wall finishes, internal and external applications.; NameAndIdentificationNumberOfNotifiedLaboratory: n/a; ReactionToFire: Class A1 (wall) ; Class A1fl (floor); ReleaseOfDangerousSubstanceCadmium: NPD; ReleaseOfDangerousSubstanceLead: NPD; SlipperinessDIN51131_Tribometer: n/a; SlipperinessXPCENTS16165_RampTest: n/a; SystemOfAssessmentAndVerificationOfCostancyOfPperformance: System 4; Tactility: NPD; TensileStrengthOrModulusOfRupture: 50 N/mm2; ThermalShockResistance: Pass; UNIMarkCertification: On request; UniqueIdentificationCodeOfTheProductType: Dry-pressed ceramic tiles,with water absorption Eb<0,5%; UPECMarkCertification: http://webapp.cstb.fr/upec-ceramique/index.php?view=TitulaireListeProduits&sid=42&tid=1
COBie_ServiceLife - ExpectedLife: 50
COBie_EconomicImpactValues - ReplacementCost: 0
COBie_Component - InstallationDate: 31/12/1900 23:59:59; WarrantyStartDate: n/a; TagNumber: n/a; AssetIdentifier: n/a
Pset_CoveringFlooring - HasNonSkidSurface: yes; HasAntiStaticSurface: no
Pset_Condition - AssessmentDate: 31/12/1900 23:59:59; AssessmentCondition: n/a; AssessmentDescription: n/a
Pset_CoveringCommon - Reference: full body porcelain stoneware (UGL); AcousticRating: n/a; FlammabilityRating: Class A1 (wall) ; Class A1fl (floor); FragilityRating: n/a; Combustible: no; SurfaceSpreadOfFlame: Class A; FireRating: Class A1 (wall) ; Class A1fl (floor)
COBie_Asset - AssetType: Fixed
COBie_Specification - Grade: n/a; Material: Porcelain stoneware tile; Constituents: n/a; Features: n/a; AccessibilityPerformance: n/a; CodePerformance: n/a; SustainabilityPerformance: n/a
COBie_Warranty - WarrantyGuarantorParts: n/a; WarrantyDurationParts: 0; WarrantyGuarantorLabor: n/a; WarrantyDurationLabor: 0; WarrantyDescription: n/a
Pset_ManufacturerTypeInformation - GlobalTradeItemNumber: n/a; ModelReference: Limestone; Manufacturer: Cotto d'Este (Panariagroup Industrie Ceramiche S.p.A.); ProductionYear: n/a
Pset_EnvironmentalImpactIndicators - Reference: full body porcelain stoneware (UGL); FunctionalUnitReference: 1 mq (m2); Unit: 1 mq (m2); LifeCyclePhase: Manufacture; ExpectedServiceLife: 50 s; TotalPrimaryEnergyConsumptionPerUnit: 242.3; WaterConsumptionPerUnit: 0.0549 m3; HazardousWastePerUnit: 0.000603 g; NonHazardousWastePerUnit: 1.36 g; ClimateChangePerUnit: 12 g; AtmosphericAcidificationPerUnit: 0.0241 g; RenewableEnergyConsumptionPerUnit: 47.3; NonRenewableEnergyConsumptionPerUnit: 195; ResourceDepletionPerUnit: 0.000075 g; InertWastePerUnit: 0 g; RadioactiveWastePerUnit: 0.00326 g; StratosphericOzoneLayerDestructionPerUnit: 0 g; PhotochemicalOzoneFormationPerUnit: 0.00183 g; EutrophicationPerUnit: 0.0037 g
Pset_EnvironmentalImpactValues - TotalPrimaryEnergyConsumption: 0; WaterConsumption: 0 m3; HazardousWaste: 0 g; NonHazardousWaste: 0 g; ClimateChange: 0 g; AtmosphericAcidification: 0 g; RenewableEnergyConsumption: 0; NonRenewableEnergyConsumption: 0; ResourceDepletion: 0 g; InertWaste: 0 g; RadioactiveWaste: 0 g; StratosphericOzoneLayerDestruction: 0 g; PhotochemicalOzoneFormation: 0 g; Eutrophication: 0 g; LeadInTime: 0; Duration: 0; LeadOutTime: 0
Pset_ServiceLife - ServiceLifeDuration: 50; MeanTimeBetweenFailure: n/a
Pset_Warranty - WarrantyIdentifier: n/a; WarrantyStartDate: 31/12/1900 23:59:59; WarrantyEndDate: 31/12/1900 23:59:59; IsExtendedWarranty: no; WarrantyPeriod: n/a; WarrantyContent: n/a; PointOfContact: n/a; Exclusions: n/a
COBie - BarCode: n/a; Category: Pr_35_93_96_19:Ceramic tiles; Description: Stone Effect; DurationUnit: Year; Manufacturer: Cotto d'Este (Panariagroup Industrie Ceramiche S.p.A.); ModelNumber: n/a; ModelReference: Limestone; SerialNumber: n/a; WarrantyDurationUnit: Year
Name | AntibacterialProperties | BreakingStrength | SlipperinessBCRA_Tribometer | SlipperinessBOT3000_Tribometer | SlipperinessBS7976-2_PendulumTester | SlipperinessDIN51097_RampBarefoot | SlipperinessDIN51130_RampWithOil | SlipperinessENV12633_PendulumTester | UNIMark | UPECmark | Pset_CoveringCommon, Finish | IsExternal | ThermalTransmittance (W/K/m2) | NominalLength (mm) | NominalWidth (mm) | NominalHeight (mm) | Shape | Size | Color | COBie_Specification, Finish | ArticleNumber | ModelLabel | Name
Limestone Amber Nat Ret 90x90 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B | R10 | Clase 1 | no | yes | Natural Rectified | yes | 92 | 900 | 900 | 14 | Square | 900x900x14 mm | Amber | Natural Rectified | EGGLS00 | Amber Natural | Amber Nat Ret 90x90
Limestone Clay Nat Ret 90x90 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B | R10 | Clase 1 | no | yes | Natural Rectified | no | 92 | 900 | 900 | 14 | Square | 900x900x14 mm | Clay | Natural Rectified | EGGLS10 | Clay Natural | Clay Nat Ret 90x90
Limestone Oyster Nat Ret 90x90 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B | R10 | Clase 1 | no | yes | Natural Rectified | no | 92 | 900 | 900 | 14 | Square | 900x900x14 mm | Oyster | Natural Rectified | EGGLS20 | Oyster Natural | Oyster Nat Ret 90x90
Limestone Slate Nat Ret 90x90 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B | R10 | Clase 1 | no | yes | Natural Rectified | no | 92 | 900 | 900 | 14 | Square | 900x900x14 mm | Slate | Natural Rectified | EGGLS30 | Slate Natural | Slate Nat Ret 90x90
Limestone Amber Honed Ret 90x90 | Protect - test report available | 6080 N | NPD | NPD | NPD | NPD | NPD | NPD | no | yes | Honed Rectified | no | 92 | 900 | 900 | 14 | Square | 900x900x14 mm | Amber | Honed Rectified | EGGLSH0 | Amber Honed | Amber Honed Ret 90x90
Limestone Clay Honed Ret 90x90 | Protect - test report available | 6080 N | NPD | NPD | NPD | NPD | NPD | NPD | no | yes | Honed Rectified | no | 92 | 900 | 900 | 14 | Square | 900x900x14 mm | Clay | Honed Rectified | EGGLSH1 | Clay Honed | Clay Honed Ret 90x90
Limestone Oyster Honed Ret 90x90 | Protect - test report available | 6080 N | NPD | NPD | NPD | NPD | NPD | NPD | no | yes | Honed Rectified | no | 92 | 900 | 900 | 14 | Square | 900x900x14 mm | Oyster | Honed Rectified | EGGLSH2 | Oyster Honed | Oyster Honed Ret 90x90
Limestone Slate Honed Ret 90x90 | Protect - test report available | 6080 N | NPD | NPD | NPD | NPD | NPD | NPD | no | yes | Honed Rectified | no | 92 | 900 | 900 | 14 | Square | 900x900x14 mm | Slate | Honed Rectified | EGGLSH3 | Slate Honed | Slate Honed Ret 90x90
Limestone Amber Nat Ret 60x120 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B | R10 | Clase 1 | no | yes | Natural Rectified | no | 92 | 1200 | 600 | 14 | Rectangle | 600x1200x14 mm | Amber | Natural Rectified | EGXLS01 | Amber Natural | Amber Nat Ret 60x120
Limestone Clay Nat Ret 60x120 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B | R10 | Clase 1 | no | yes | Natural Rectified | no | 92 | 1200 | 600 | 14 | Rectangle | 600x1200x14 mm | Clay | Natural Rectified | EGXLS11 | Clay Natural | Clay Nat Ret 60x120
Limestone Oyster Nat Ret 60x120 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B | R10 | Clase 1 | no | yes | Natural Rectified | no | 92 | 1200 | 600 | 14 | Rectangle | 600x1200x14 mm | Oyster | Natural Rectified | EGXLS21 | Oyster Natural | Oyster Nat Ret 60x120
Limestone Slate Nat Ret 60x120 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B | R10 | Clase 1 | no | yes | Natural Rectified | no | 92 | 1200 | 600 | 14 | Rectangle | 600x1200x14 mm | Slate | Natural Rectified | EGXLS31 | Slate Natural | Slate Nat Ret 60x120
Limestone Amber Honed Ret 60x120 | Protect - test report available | 6080 N | NPD | NPD | NPD | NPD | NPD | NPD | no | yes | Honed Rectified | no | 92 | 1200 | 600 | 14 | Rectangle | 600x1200x14 mm | Amber | Honed Rectified | EGXLS01 | Amber Honed | Amber Honed Ret 60x120
Limestone Clay Honed Ret 60x120 | Protect - test report available | 6080 N | NPD | NPD | NPD | NPD | NPD | NPD | no | yes | Honed Rectified | no | 92 | 1200 | 600 | 14 | Rectangle | 600x1200x14 mm | Clay | Honed Rectified | EGXLS11 | Clay Honed | Clay Honed Ret 60x120
Limestone Oyster Honed Ret 60x120 | Protect - test report available | 6080 N | NPD | NPD | NPD | NPD | NPD | NPD | no | yes | Honed Rectified | no | 92 | 1200 | 600 | 14 | Rectangle | 600x1200x14 mm | Oyster | Honed Rectified | EGXLS21 | Oyster Honed | Oyster Honed Ret 60x120
Limestone Slate Honed Ret 60x120 | Protect - test report available | 6080 N | NPD | NPD | NPD | NPD | NPD | NPD | no | yes | Honed Rectified | no | 92 | 1200 | 600 | 14 | Rectangle | 600x1200x14 mm | Slate | Honed Rectified | EGXLS31 | Slate Honed | Slate Honed Ret 60x120
Limestone Amber Blazed Ret 60x120 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B+C | R11 | Clase 3 | no | yes | Blazed Rectified | no | 92 | 1200 | 600 | 14 | Rectangle | 600x1200x14 mm | Amber | Blazed Rectified | EGXLS05 | Amber Blazed | Amber Blazed Ret 60x120
Limestone Clay Blazed Ret 60x120 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B+C | R11 | Clase 3 | no | yes | Blazed Rectified | no | 92 | 1200 | 600 | 14 | Rectangle | 600x1200x14 mm | Clay | Blazed Rectified | EGXLS15 | Clay Blazed | Clay Blazed Ret 60x120
Limestone Oyster Blazed Ret 60x120 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B+C | R11 | Clase 3 | no | yes | Blazed Rectified | no | 92 | 1200 | 600 | 14 | Rectangle | 600x1200x14 mm | Oyster | Blazed Rectified | EGXLS25 | Oyster Blazed | Oyster Blazed Ret 60x120
Limestone Slate Blazed Ret 60x120 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B+C | R11 | Clase 3 | yes | no | Blazed Rectified | no | 92 | 1200 | 600 | 14 | Rectangle | 600x1200x14 mm | Slate | Blazed Rectified | EGXLS35 | Slate Blazed | Slate Blazed Ret 60x120
Limestone Amber Nat Ret 60x60 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B | R10 | Clase 1 | no | yes | Natural Rectified | no | 92 | 600 | 600 | 14 | Square | 600x600x14 mm | Amber | Natural Rectified | EGWLS01 | Amber Natural | Amber Nat Ret 60x60
Limestone Clay Nat Ret 60x60 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B | R10 | Clase 1 | no | yes | Natural Rectified | no | 92 | 600 | 600 | 14 | Square | 600x600x14 mm | Clay | Natural Rectified | EGWLS11 | Clay Natural | Clay Nat Ret 60x60
Limestone Oyster Nat Ret 60x60 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B | R10 | Clase 1 | no | yes | Natural Rectified | no | 92 | 600 | 600 | 14 | Square | 600x600x14 mm | Oyster | Natural Rectified | EGWLS21 | Oyster Natural | Oyster Nat Ret 60x60
Limestone Slate Nat Ret 60x60 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B | R10 | Clase 1 | no | yes | Natural Rectified | no | 92 | 600 | 600 | 14 | Square | 600x600x14 mm | Slate | Natural Rectified | EGXLS31 | Slate Natural | Slate Nat Ret 60x60
Limestone Amber Honed Ret 60x60 | Protect - test report available | 6080 N | NPD | NPD | NPD | NPD | NPD | NPD | no | yes | Honed Rectified | no | 92 | 600 | 600 | 14 | Square | 600x600x14 mm | Amber | Honed Rectified | EGWLSH0 | Amber Honed | Amber Honed Ret 60x60
Limestone Clay Honed Ret 60x60 | Protect - test report available | 6080 N | NPD | NPD | NPD | NPD | NPD | NPD | no | yes | Honed Rectified | no | 92 | 600 | 600 | 14 | Square | 600x600x14 mm | Clay | Honed Rectified | EGWLSH1 | Clay Honed | Clay Honed Ret 60x60
Limestone Oyster Honed Ret 60x60 | Protect - test report available | 6080 N | NPD | NPD | NPD | NPD | NPD | NPD | no | yes | Honed Rectified | no | 92 | 600 | 600 | 14 | Square | 600x600x14 mm | Oyster | Honed Rectified | EGWLSH2 | Oyster Honed | Oyster Honed Ret 60x60
Limestone Slate Honed Ret 60x60 | Protect - test report available | 6080 N | NPD | NPD | NPD | NPD | NPD | NPD | no | yes | Honed Rectified | no | 92 | 600 | 600 | 14 | Square | 600x600x14 mm | Slate | Honed Rectified | EGWLSH3 | Slate Honed | Slate Honed Ret 60x60
Limestone Amber Blazed Ret 60x60 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B+C | R11 | Clase 3 | no | yes | Blazed Rectified | no | 92 | 600 | 600 | 14 | Square | 600x600x14 mm | Amber | Blazed Rectified | EGWLS05 | Amber Blazed | Amber Blazed Ret 60x60
Limestone Clay Blazed Ret 60x60 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B+C | R11 | Clase 3 | no | yes | Blazed Rectified | no | 92 | 600 | 600 | 14 | Square | 600x600x14 mm | Clay | Blazed Rectified | EGWLS15 | Clay Blazed | Clay Blazed Ret 60x60
Limestone Oyster Blazed Ret 60x60 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B+C | R11 | Clase 3 | no | yes | Blazed Rectified | no | 92 | 600 | 600 | 14 | Square | 600x600x14 mm | Oyster | Blazed Rectified | EGWLS25 | Oyster Blazed | Oyster Blazed Ret 60x60
Limestone Slate Blazed Ret 60x60 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B+C | R11 | Clase 3 | no | yes | Blazed Rectified | no | 92 | 600 | 600 | 14 | Square | 600x600x14 mm | Slate | Blazed Rectified | EGWLS35 | Slate Blazed | Slate Blazed Ret 60x60
Limestone Amber Nat Ret 30x60 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B | R10 | Clase 1 | no | yes | Natural Rectified | no | 92 | 600 | 300 | 14 | Rectangle | 300x600x14 mm | Amber | Natural Rectified | EG-LS00 | Amber Natural | Amber Nat Ret 30x60
Limestone Clay Nat Ret 30x60 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B | R10 | Clase 1 | no | yes | Natural Rectified | no | 92 | 600 | 300 | 14 | Rectangle | 300x600x14 mm | Clay | Natural Rectified | EG-LS10 | Clay Natural | Clay Nat Ret 30x60
Limestone Oyster Nat Ret 30x60 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B | R10 | Clase 1 | no | yes | Natural Rectified | no | 92 | 600 | 300 | 14 | Rectangle | 300x600x14 mm | Oyster | Natural Rectified | EG-LS20 | Oyster Natural | Oyster Nat Ret 30x60
Limestone Slate Nat Ret 30x60 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B | R10 | Clase 1 | no | yes | Natural Rectified | no | 92 | 600 | 300 | 14 | Rectangle | 300x600x14 mm | Slate | Natural Rectified | EG-LS30 | Slate Natural | Slate Nat Ret 30x60
Limestone Amber Honed Ret 30x60 | Protect - test report available | 6080 N | NPD | NPD | NPD | NPD | NPD | NPD | no | yes | Honed Rectified | no | 92 | 600 | 300 | 14 | Rectangle | 300x600x14 mm | Amber | Honed Rectified | EG-LSH0 | Amber Honed | Amber Honed Ret 30x60
Limestone Clay Honed Ret 30x60 | Protect - test report available | 6080 N | NPD | NPD | NPD | NPD | NPD | NPD | no | yes | Honed Rectified | no | 92 | 600 | 300 | 14 | Rectangle | 300x600x14 mm | Clay | Honed Rectified | EG-LSH1 | Clay Honed | Clay Honed Ret 30x60
Limestone Oyster Honed Ret 30x60 | Protect - test report available | 6080 N | NPD | NPD | NPD | NPD | NPD | NPD | no | yes | Honed Rectified | no | 92 | 600 | 300 | 14 | Rectangle | 300x600x14 mm | Oyster | Honed Rectified | EG-LSH2 | Oyster Honed | Oyster Honed Ret 30x60
Limestone Slate Honed Ret 30x60 | Protect - test report available | 6080 N | NPD | NPD | NPD | NPD | NPD | NPD | no | yes | Honed Rectified | no | 92 | 600 | 300 | 14 | Rectangle | 300x600x14 mm | Slate | Honed Rectified | EG-LSH3 | Slate Honed | Slate Honed Ret 30x60
Limestone Amber Blazed Ret 30x60 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B+C | R11 | Clase 3 | no | yes | Blazed Rectified | no | 92 | 600 | 300 | 14 | Rectangle | 300x600x14 mm | Amber | Blazed Rectified | EG-LS05 | Amber Blazed | Amber Blazed Ret 30x60
Limestone Clay Blazed Ret 30x60 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B+C | R11 | Clase 3 | no | yes | Blazed Rectified | no | 92 | 600 | 300 | 14 | Rectangle | 300x600x14 mm | Clay | Blazed Rectified | EG-LS15 | Clay Blazed | Clay Blazed Ret 30x60
Limestone Oyster Blazed Ret 30x60 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B+C | R11 | Clase 3 | no | yes | Blazed Rectified | no | 92 | 600 | 300 | 14 | Rectangle | 300x600x14 mm | Oyster | Blazed Rectified | EG-LS25 | Oyster Blazed | Oyster Blazed Ret 30x60
Limestone Slate Blazed Ret 30x60 | Protect - test report available | 6080 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B+C | R11 | Clase 3 | no | yes | Blazed Rectified | no | 92 | 600 | 300 | 14 | Rectangle | 300x600x14 mm | Slate | Blazed Rectified | EG-LS35 | Slate Blazed | Slate Blazed Ret 30x60
Limestone Amber Fiammata Ret 90x90 20mm | n/a | 13600 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B+C | R11 | Clase 3 | no | yes | Fiammata Rectified 20mm | yes | 65 | 900 | 900 | 20 | Square | 900x900x20 mm | Amber | Fiammata Rectified | EGGLS90 | Amber Fiammata | Amber Fiammata Ret 90x90
Limestone Clay Fiammata Ret 90x90 20mm | n/a | 13600 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B+C | R11 | Clase 3 | no | yes | Fiammata Rectified 20mm | yes | 65 | 900 | 900 | 20 | Square | 900x900x20 mm | Clay | Fiammata Rectified | EGGLS91 | Clay Fiammata | Clay Fiammata Ret 90x90
Limestone Oyster Fiammata Ret 90x90 20 mm | n/a | 13600 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B+C | R11 | Clase 3 | no | yes | Fiammata Rectified 20mm | yes | 65 | 900 | 900 | 20 | Square | 900x900x20 mm | Oyster | Fiammata Rectified | EGGLS92 | Oyster Fiammata | Oyster Fiammata Ret 90x90
Limestone Slate Fiammata Ret 90x90 20mm | n/a | 13600 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B+C | R11 | Clase 3 | no | yes | Fiammata Rectified 20mm | yes | 65 | 900 | 900 | 20 | Square | 900x900x20 mm | Slate | Fiammata Rectified | EGGLS93 | Slate Fiammata | Slate Fiammata Ret 90x90
Limestone Amber Fiammata Ret 60x120 20mm | n/a | 13600 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B+C | R11 | Clase 3 | no | yes | Fiammata Rectified 20mm | yes | 65 | 1200 | 600 | 20 | Rectangle | 600x1200x20 mm | Amber | Fiammata Rectified | EGXLS60 | Amber Fiammata | Amber Fiammata Ret 90x90
Limestone Clay Fiammata Ret 60x120 20 mm | n/a | 13600 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B+C | R11 | Clase 3 | no | yes | Fiammata Rectified 20mm | yes | 65 | 1200 | 600 | 20 | Rectangle | 600x1200x20 mm | Clay | Fiammata Rectified | EGXLS61 | Clay Fiammata | Clay Fiammata Ret 90x90
Limestone Oyster Fiammata Ret 60x120 20mm | n/a | 13600 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B+C | R11 | Clase 3 | no | yes | Fiammata Rectified 20mm | yes | 65 | 1200 | 600 | 20 | Rectangle | 600x1200x20 mm | Oyster | Fiammata Rectified | EGXLS62 | Oyster Fiammata | Oyster Fiammata Ret 90x90
Limestone Slate Fiammata Ret 60x120 20 mm | n/a | 13600 N | μ > 0,40 | DCOF ≥ 0.42 | PTV 36+ wet Sl.96 | A+B+C | R11 | Clase 3 | no | yes | Fiammata Rectified 20mm | yes | 65 | 1200 | 600 | 20 | Rectangle | 600x1200x20 mm | Slate | Fiammata Rectified | EGXLS63 | Slate Fiammata | Slate Fiammata Ret 90x90
